
EXTRA_OECMAKE += "-DSPDLOG_BUILD_SHARED=ON"